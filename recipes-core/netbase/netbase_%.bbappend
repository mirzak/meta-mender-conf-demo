MENDER_DEMO_HOST_IP_ADDRESS = "192.168.1.120"
MENDER_DEMO_HOST_IP_ADDRESS_vexpress-qemu = ""
MENDER_DEMO_HOST_IP_ADDRESS_vexpress-qemu-flash = ""
